# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F427VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\Peripheral;..\Driver
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c systick.c
  group Peripheral
    ../Peripheral/: gd32f4xx_adc.c gd32f4xx_adc.h gd32f4xx_can.c gd32f4xx_can.h gd32f4xx_crc.c gd32f4xx_crc.h gd32f4xx_ctc.c gd32f4xx_ctc.h gd32f4xx_dac.c gd32f4xx_dac.h gd32f4xx_dbg.c gd32f4xx_dbg.h gd32f4xx_dci.c gd32f4xx_dci.h gd32f4xx_dma.c gd32f4xx_dma.h gd32f4xx_enet.c gd32f4xx_enet.h gd32f4xx_exmc.c gd32f4xx_exmc.h gd32f4xx_exti.c gd32f4xx_exti.h gd32f4xx_fmc.c gd32f4xx_fmc.h gd32f4xx_fwdgt.c gd32f4xx_fwdgt.h gd32f4xx_gpio.c gd32f4xx_gpio.h gd32f4xx_i2c.c gd32f4xx_i2c.h gd32f4xx_ipa.c gd32f4xx_ipa.h gd32f4xx_iref.c gd32f4xx_iref.h gd32f4xx_misc.c gd32f4xx_misc.h gd32f4xx_pmu.c gd32f4xx_pmu.h gd32f4xx_rcu.c gd32f4xx_rcu.h gd32f4xx_rtc.c gd32f4xx_rtc.h gd32f4xx_sdio.c gd32f4xx_sdio.h gd32f4xx_spi.c gd32f4xx_spi.h gd32f4xx_syscfg.c gd32f4xx_syscfg.h gd32f4xx_timer.c gd32f4xx_timer.h gd32f4xx_tli.c gd32f4xx_tli.h gd32f4xx_trng.c gd32f4xx_trng.h gd32f4xx_usart.c gd32f4xx_usart.h gd32f4xx_wwdgt.c gd32f4xx_wwdgt.h
  group CMSIS
    ../CMSIS/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h gd32f4xx.h system_gd32f4xx.c system_gd32f4xx.h gd32f4xx_libopt.h
  group Startup
    ../Startup/: startup_gd32f407_427.s
  group Driver
    ../Driver/: uart.c uart.h gpio.c gpio.h spi.c spi.h
